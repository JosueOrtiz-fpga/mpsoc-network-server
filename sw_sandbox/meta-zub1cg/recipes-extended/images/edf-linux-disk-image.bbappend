#---
# Remove uneeded packagegroup which requires commercial license
#  acceptance but is only used for ZynqMPs with VCUs
#---
AMD_CORTEXA53_COMMON_INSTALL:remove="packagegroup-xilinx-gstreamer"